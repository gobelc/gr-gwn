<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gwncppvgb_gwnmsg_sink</key>
<param><key>id</key><value>gwncppvgb_gwnmsg_sink_0</value></param>
</block>
<block>
<key>gwncppvgb_gwnmsg_source</key>
<param><key>id</key><value>gwncppvgb_gwnmsg_source_0</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>msg</key><value>"mensaje"</value></param>
</block>
<block>
<key>gwncppvgb_virtual_channel</key>
<param><key>id</key><value>gwncppvgb_virtual_channel_0</value></param>
<param><key>prob_loss</key><value>.90</value></param>
</block>
<connection><source_block_id>gwncppvgb_gwnmsg_source_0</source_block_id><sink_block_id>gwncppvgb_virtual_channel_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
<connection><source_block_id>gwncppvgb_virtual_channel_0</source_block_id><sink_block_id>gwncppvgb_gwnmsg_sink_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
</flow_graph>
